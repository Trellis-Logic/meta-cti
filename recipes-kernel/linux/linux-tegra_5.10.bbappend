SRCBRANCH:connecttech = "cti-patches-r35.6.0-v005-oe4t-patches-l4t"

SRCREV:connecttech = "f430738b03fe11bccbf6d666ec4db2bcc5f5c3df"

SRC_REPO:connecttech = "github.com/Trellis-Logic/linux-tegra-5.10.git;protocol=https"

KBUILD_DEFCONFIG:connecttech = "cti_tegra_defconfig"
